Commit message: new version

File: assets/ur5_rq_gsmini_wo_cover.urdf (robot description, URDF)
Before this commit: robot ur5, 22 links, 21 joints
Links:
- link left_box: geometry collision box size=0.026 0.022 0.013
- link right_box: geometry collision box size=0.026 0.022 0.013
